Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 0b390b73-6cae-4930-ac5f-812a58390e26, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-06T09:47:27+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 95275780_EU1_KWT6722iGS-1_RE:95275780_EU1_95275780_KWT6722iGS-1_RE, (2)
In: Default
Type - Material: Výchozí Nový materiál(1), z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Alusilver, Default New Material, Poche, z_Miele_Design_CLST, z_Miele_Design_Glass, <Unnamed>, z_Miele_Design_BRWS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 557 mm; Height: 1770 mm; Depth: 572 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 95275780_EU1_95275780_KWT6722iGS-1_RE; sets with these values: 2

# IfcDistributionPort, Port_361815_1
Description: Flow; FlowDirection: SOURCEANDSINK
